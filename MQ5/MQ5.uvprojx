# Keil uVision project MQ5.uvprojx, settings and files
target MQ5 (6240000::V6.24::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: MQ5 +hex
  AfterMake: fromelf  --bin --output .\Objects\@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_DEPRECATED_DEFINITION
  c include: .\CMSIS;.\Application;.\Application\Bsw\Common;.\Application\Bsw\Mcal
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ./CMSIS/: startup_LX61101.s system_LX61101.c device_LX61101.c interrupt_LX61101.c
  group Application
    ./Application/: main.c
  group Bsw/Mcal
    ./Application/Bsw/Mcal/: Dio.c Tms.c Spi.c Adc.c
software components: CMSIS:CORE 6.4.0
